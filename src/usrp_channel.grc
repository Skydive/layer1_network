options:
  parameters:
    generate_options: qt_gui
    id: fm_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: center_freq
    start: 99.5e6
    step: 100e3
    stop: 140.0e6
    value: 100.2e6
  states: {}
- name: in_gain
  id: variable_qtgui_entry
  parameters:
    label: Receive Gain
    type: real
    value: '40'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: out_gain
  id: variable_qtgui_entry
  parameters:
    label: gain
    type: real
    value: '50'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: center_freq
    clock_rate: 30.72e6
    clock_source0: internal
    gain0: out_gain
    samp_rate: usrp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(center_freq, 180000)
    clock_rate: 30.72e6
    dev_addr: ''
    gain0: out_gain
    rx_agc0: Disabled
    samp_rate: usrp_rate
    sd_spec0: A:B
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49202
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [channels_channel_model_0, '0', zeromq_pub_sink_0, '0']
- [uhd_usrp_source_0_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_source_0_0, '0', channels_channel_model_0, '0']
- [zeromq_sub_source_0_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
